## sdkconfig.defaults
```kconfig
# ESP32-S3 SuperMini 是 4MB Flash
CONFIG_ESPTOOLPY_FLASHSIZE_4MB=y
CONFIG_ESPTOOLPY_FLASHSIZE="4MB"
```
